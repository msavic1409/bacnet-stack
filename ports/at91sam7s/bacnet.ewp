# IAR project bacnet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BACDL_MSTP; MAX_APDU=480; BIG_ENDIAN=0; MAX_TSM_TRANSACTIONS=0; BACAPP_BOOLEAN; BACAPP_REAL; BACAPP_OBJECT_ID; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\include; ..\..\demo\object
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: ai.c av.c bi.c bv.c device.c dlmstp.c init.c irq.c main.c rs485.c timer.c
  group BACnet
    ../../src/: abort.c apdu.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c datalink.c dcc.c fifo.c iam.c ihave.c memcopy.c npdu.c proplist.c rd.c reject.c ringbuf.c rp.c rpm.c version.c whohas.c whois.c wp.c
  group BACnet-Handlers
    ../../demo/handler/: h_dcc.c h_npdu.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c noserv.c s_iam.c s_ihave.c txbuf.c
